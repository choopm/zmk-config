## config/boards/shields/redox/Kconfig.shield
```kconfig
# No whitespace after the comma or in the keyboard name!
config SHIELD_REDOX_DONGLE
    def_bool $(shields_list_contains,redox_dongle)
```
